# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; __SAMD20J18__; BOARD=SAMD20_XPLAINED_PRO; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../sam0/utils/cmsis/samd20/source; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../sam0/drivers/system/interrupt; ../../../sam0; ../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ..; ../../../../../../common/boards; ../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../sam0/utils/cmsis/samd20/include/: samd20g16.h samd20g14.h samd20j18.h samd20g17.h samd20j15.h samd20g15.h samd20j17.h samd20e16.h samd20j14.h samd20j16.h samd20e14.h samd20e18.h samd20e17.h samd20.h samd20e15.h samd20g17u.h samd20g18u.h samd20g18.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../sam0/utils/cmsis/samd20/include/instance/: wdt.h pac2.h sysctrl.h gclk.h pac0.h ac.h dac.h tc0.h adc.h dsu.h rtc.h port.h tc6.h sercom2.h tc1.h sercom4.h pm.h tc5.h nvmctrl.h sercom0.h tc3.h tc7.h sercom3.h tc4.h sercom5.h evsys.h tc2.h sercom1.h eic.h pac1.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../sam0/utils/cmsis/samd20/include/component/: wdt.h sysctrl.h evsys.h rtc.h sercom.h dac.h tc.h gclk.h dsu.h port.h eic.h adc.h pm.h ac.h pac.h nvmctrl.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../sam0/utils/cmsis/samd20/include/pio/: samd20j18.h samd20e14.h samd20j16.h samd20e18.h samd20g14.h samd20g17.h samd20j14.h samd20g16.h samd20e17.h samd20g18u.h samd20j17.h samd20e15.h samd20j15.h samd20g17u.h samd20g18.h samd20g15.h samd20e16.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../sam0/drivers/system/clock/clock_samd20/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samd20_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/samd20_xplained_pro/iar
    ./: asf.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
