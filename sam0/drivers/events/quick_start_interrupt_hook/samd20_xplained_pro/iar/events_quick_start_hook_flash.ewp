# IAR project events_quick_start_hook_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EVENTS_INTERRUPT_HOOKS_MODE=true; ARM_MATH_CM0PLUS=true; __SAMD20J18__; BOARD=SAMD20_XPLAINED_PRO; TC_ASYNC=false
  ICCARM.CCIncludePath2: ../../../../system/clock/clock_samd20; ../../../../system/power; ../../../../system/reset; ../../../../../utils/preprocessor; ../../../../../boards/samd20_xplained_pro; ../../../../../utils/cmsis/samd20/source; ..; ../../../../../utils; ../..; ../../../../port; ../../../../../boards; ../../../../system/reset/reset_sam_d_r_h; ../../../../../../common/utils; ../../../events_sam_d_r_h; ../../../../system/interrupt/system_interrupt_samd20; ../../../../system/interrupt; ../../../../tc; ../../../../system/power/power_sam_d_r_h; ../../../../tc/tc_sam_d_r_h; ../../../../../../common/boards; ../../../../../utils/cmsis/samd20/include; ../../../../system/pinmux; ../../../../system; ../../..; ../../../../../utils/header_files; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: events_quick_start_hook_flash.bin
  ILINK.IlinkOutputFile: events_quick_start_hook_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../utils/cmsis/samd20/include/: samd20.h samd20j14.h samd20j16.h samd20j18.h samd20j17.h samd20g18.h samd20e17.h samd20g17u.h samd20e15.h samd20g17.h samd20e16.h samd20g18u.h samd20g15.h samd20e14.h samd20g16.h samd20e18.h samd20j15.h samd20g14.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../utils/cmsis/samd20/include/pio/: samd20e15.h samd20j15.h samd20j17.h samd20e17.h samd20j16.h samd20g18.h samd20e18.h samd20j14.h samd20g18u.h samd20j18.h samd20g14.h samd20g16.h samd20g15.h samd20g17.h samd20g17u.h samd20e16.h samd20e14.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../utils/cmsis/samd20/include/component/: dac.h adc.h port.h wdt.h sysctrl.h evsys.h pm.h pac.h dsu.h ac.h eic.h tc.h sercom.h rtc.h nvmctrl.h gclk.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../utils/cmsis/samd20/include/instance/: pac1.h evsys.h sercom5.h sercom0.h sysctrl.h sercom3.h dsu.h dac.h ac.h sercom4.h adc.h sercom2.h tc7.h rtc.h tc3.h tc1.h pac2.h nvmctrl.h tc5.h pm.h wdt.h port.h tc6.h gclk.h pac0.h tc0.h eic.h sercom1.h tc4.h tc2.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../system/clock/clock_samd20/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/events
    ../../../: events_hooks.c events_hooks.h events.h events_common.h
  group sam0/drivers/events/quick_start_interrupt_hook
    ../../: qs_events_interrupt_hook.c qs_events_interrupt_hook.h
  group sam0/drivers/events/quick_start_interrupt_hook/samd20_xplained_pro
    ../: conf_board.h conf_qs_events_interrupt_hook.h conf_clocks.h
  group sam0/drivers/events/quick_start_interrupt_hook/samd20_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/events/events_sam_d_r_h
    ../../../events_sam_d_r_h/: events.c
  group sam0/drivers/tc
    ../../../../tc/: tc.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
