# IAR project bod_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMHA1G16A Atmel ATSAMHA1G16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMHA1G16A_XPLAINED_PRO; __SAMHA1G16A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../..; ../../../../port; ../../../../../utils/cmsis/samha1/include; ../../../../../boards; ../../../../../../common/boards; ../../../../system/pinmux; ../../../../../utils/preprocessor; ..; ../../../../../utils/header_files; ../../../../../../common/utils; ../../../../../utils; ../..; ../../../../../boards/samha1g16a_xplained_pro; ../../../bod_sam_d_r_h; ../../../../../utils/cmsis/samha1/source; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bod_quick_start_flash.bin
  ILINK.IlinkOutputFile: bod_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samha1/iar/samha1g16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/bod
    ../../../: bod.h
  group sam0/drivers/bod/quick_start
    ../../: qs_bod_basic_use.c
  group sam0/drivers/bod/quick_start/samha1g16a_xplained_pro
    ../: conf_board.h
  group sam0/drivers/bod/quick_start/samha1g16a_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/bod/bod_sam_d_r_h
    ../../../bod_sam_d_r_h/: bod.c bod_feature.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/utils
    ../../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samha1/source
    ../../../../../utils/cmsis/samha1/source/: system_samha1.c system_samha1.h
  group sam0/utils/cmsis/samha1/source/iar
    ../../../../../utils/cmsis/samha1/source/iar/: startup_samha1.c
  group sam0/utils/cmsis/samha1/include
    ../../../../../utils/cmsis/samha1/include/: samha1g14a.h samha1g15a.h samha1.h samha1g16a.h
  group sam0/utils/cmsis/samha1/include/component
    ../../../../../utils/cmsis/samha1/include/component/: linctrl.h dmac.h hmatrixb.h rtc.h sercom.h mtb.h tc.h port.h evsys.h ac.h dac.h pm.h adc.h gclk.h wdt.h pac.h sysctrl.h nvmctrl.h tcc.h dsu.h eic.h
  group sam0/utils/cmsis/samha1/include/instance
    ../../../../../utils/cmsis/samha1/include/instance/: nvmctrl.h dsu.h ac.h tc7.h linctrl.h pac0.h evsys.h wdt.h pm.h tc6.h dac.h rtc.h eic.h sercom1.h sercom0.h sercom4.h sercom3.h sercom2.h port.h pac2.h pac1.h tcc0.h dmac.h tcc1.h tcc2.h tc3.h tc5.h adc.h tc4.h gclk.h sysctrl.h sercom5.h sbmatrix.h mtb.h
  group sam0/utils/cmsis/samha1/include/pio
    ../../../../../utils/cmsis/samha1/include/pio/: samha1g15a.h samha1g16a.h samha1g14a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: preprocessor.h stringz.h mrecursion.h mrepeat.h tpaste.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samha1g16a_xplained_pro
    ../../../../../boards/samha1g16a_xplained_pro/: board_init.c samha1g16a_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
