# IAR project dev_ncp_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SAL_TYPE=AT86RF2xx; BEACON_SUPPORT; DISABLE_TSTAMP_IRQ=1; ANTENNA_DIVERSITY=0; BOARD=SAMD20_XPLAINED_PRO; _DEBUG_=0; TC_ASYNC=true; GTS_SUPPORT; ARM_MATH_CM0PLUS=true; SPI_CALLBACK_MODE=false; ENABLE_DEEP_SLEEP; PAL_USE_SPI_TRX=1; STB_ON_SAL; EXTINT_CALLBACK_MODE=true; ENABLE_TSTAMP; USART_CALLBACK_MODE=true; SYSTICK_MODE; RTC_COUNT_ASYNC=true; TAL_TYPE=AT86RF233; HIGHEST_STACK_LAYER=MAC; SIO_HUB; __SAMD20J18__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../../source/mac/inc; ../../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ..; ../..; ../../../../../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../../../services/sal/inc; ../../../../../../../../../../common2/services/delay; ../../../../../../../source/resources/queue/inc; ../../../../../../../../../../sam0/utils; ../../../../../../../../services/trx_access; ../../../../../../../include; ../../../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../../sam0/drivers/port; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../services/common_hw_timer/sam0; ../../../../../../../../../../common/services/serial; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h; ../../../../../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../source/resources/buffer/inc; ../../../../../../../../../../common/utils; ../../../../../../../source/tal/at86rf233/inc; ../../../../../../../../../../sam0/utils/cmsis/samd20/source; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../../sam0/drivers/tc; ../../../../../../../../../../sam0/drivers/rtc; ../../../../../../../../services/common_hw_timer; ../../../../../../../source/stb/inc; ../../../../../../../source/tal/inc; ../../../../../../../source/pal; ../../../../../../../../../../common2/services/delay/sam0; ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../../../../../../../common/boards; ../../../../../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../addons/sio2host/uart; ../../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dev_ncp_flash.bin
  ILINK.IlinkOutputFile: dev_ncp_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../../../../services/sal/inc/: sal_types.h sal.h sal_generic.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../source/mac/src/: mac_beacon.c mac_start.c mac_associate.c mac_mcps_data.c mac_data_ind.c mac_orphan.c mac.c mac_scan.c mac_sync.c mac_misc.c mac_api.c mac_callback_wrapper.c mac_rx_enable.c mac_gts.c mac_pib.c mac_disassociate.c mac_security.c mac_data_extract_mhr.c mac_dispatcher.c mac_data_req.c mac_process_tal_tx_frame_status.c mac_poll.c mac_tx_coord_realignment_command.c mac_process_beacon_frame.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../source/mac/inc/: mac_config.h mac_internal.h mac_api.h mac_msg_type_data_ind.h mac_msg_const.h mac_security.h mac_msg_types.h mac_data_structures.h mac.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../../../source/tal/at86rf233/src/: tal_rx.c tal_init.c tal_rx_enable.c tal.c tal_ed.c tal_pwr_mgmt.c tal_pib.c tal_irq_handler.c tal_slotted_csma.c tal_tx.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../../../source/tal/at86rf233/inc/: tal_tx.h tal_pib.h tal_config.h at86rf233.h tal_irq_handler.h tal_rx.h tal_internal.h tal_constants.h tal_slotted_csma.h
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../source/tal/inc/: tal.h tal_helper.h tal_timer_config.h tal_types.h tal_generic.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../source/pal/: pal.c pal_generic.h pal.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../source/stb/src/: stb_help.c stb.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../source/stb/inc/: stb_armcrypto.h stb_internal.h stb.h stb_generic.h
  group thirdparty/wireless/avr2025_mac/apps/mac/beacon/dev
    ../../../: main.c app_security.c beacon_app.h
  group thirdparty/wireless/avr2025_mac/apps/mac/beacon/dev/ncp
    ../../: app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/mac/beacon/dev/ncp/samd20_reb233_xpro
    ../: conf_sio2host.h conf_clocks.h conf_board.h conf_sleepmgr.h conf_spi.h conf_hw_timer.h conf_extint.h
  group thirdparty/wireless/avr2025_mac/apps/mac/beacon/dev/ncp/samd20_reb233_xpro/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../include/: avr2025_mac.h stack_config.h ieee_const.h tal_build_config.h return_val.h mac_build_config.h ieee_154g.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group common/utils
    ../../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../../../../../sam0/drivers/system/clock/clock_samd20/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_interrupt.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../../sam0/drivers/sercom/usart/: usart_interrupt.c usart.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/tc
    ../../../../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/rtc
    ../../../../../../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h/: rtc_count_interrupt.c rtc_count.c
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/stdio
    ../../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../../../../sam0/utils/cmsis/samd20/include/: samd20j15.h samd20g15.h samd20j17.h samd20.h samd20j14.h samd20e18.h samd20e14.h samd20j16.h samd20j18.h samd20e16.h samd20g16.h samd20e15.h samd20g17u.h samd20g14.h samd20e17.h samd20g17.h samd20g18.h samd20g18u.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/samd20/include/instance/: sercom1.h sercom4.h sercom5.h dsu.h nvmctrl.h pac1.h wdt.h tc1.h ac.h evsys.h pac2.h dac.h pac0.h adc.h tc0.h tc2.h sysctrl.h sercom3.h sercom2.h tc7.h sercom0.h tc4.h tc6.h tc3.h rtc.h tc5.h pm.h gclk.h eic.h port.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/samd20/include/pio/: samd20e14.h samd20e17.h samd20g14.h samd20e18.h samd20g16.h samd20e16.h samd20j18.h samd20j14.h samd20g18.h samd20g17u.h samd20e15.h samd20g18u.h samd20j15.h samd20j16.h samd20j17.h samd20g15.h samd20g17.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../../../../sam0/utils/cmsis/samd20/include/component/: ac.h gclk.h dac.h tc.h sercom.h port.h evsys.h wdt.h pac.h sysctrl.h nvmctrl.h eic.h pm.h adc.h dsu.h rtc.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h mrecursion.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/services/delay
    ../../../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
