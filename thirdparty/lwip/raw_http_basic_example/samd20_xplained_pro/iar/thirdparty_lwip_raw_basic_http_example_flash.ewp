# IAR project thirdparty_lwip_raw_basic_http_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMD20_XPLAINED_PRO; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAMD20J18__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../..; ../../network/httpserver; ../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../sam0/drivers/port; ../../../lwip-1.4.1/src/include/ipv4; ../../../../../sam0/drivers/system/reset; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam0/utils/preprocessor; ../../../../../sam0/boards/samd20_xplained_pro; ../../../../../sam0/utils/cmsis/samd20/source; ../../../../../common2/services/delay; ../../../../../sam0/utils; ../../../lwip-1.4.1/src/include; ../../network; ../../../../../sam0/drivers/sercom; ../../../../../sam0/drivers/system/power; ../../../../../sam0/boards; ../../../lwip-port-1.4.1/sam/include/netif; ../../../../../sam0/drivers/sercom/usart; ../../../../../common/services/serial; ../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../common/utils; ../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../sam0/drivers/system/interrupt; ../../../../../sam0/drivers/tc; ..; ../../../../../common2/services/delay/sam0; ../../../../../sam0/drivers/sercom/spi; ../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../../sam0/drivers/system/pinmux; ../../../../../common/boards; ../../../../../sam0/utils/cmsis/samd20/include; ../../../../../sam0/components/ethernet_phy/ksz8851snl; ../../../../../sam0/drivers/system; ../../../lwip-port-1.4.1/sam/include; ../../../../../sam0/drivers/extint; ../../../../../sam0/utils/header_files; ../../../../../sam0/utils/stdio/stdio_serial; ../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_raw_basic_http_example_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_raw_basic_http_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0xa00
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c netbuf.c api_msg.c tcpip.c err.c netifapi.c netdb.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: tcp_in.c mem.c stats.c dhcp.c lwip_init.c tcp_out.c dns.c lwip_timers_141.c sys.c raw.c pbuf.c def.c netif.c udp.c tcp.c memp.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c icmp.c igmp.c ip_frag.c autoip.c ip_addr.c ip.c inet.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: def.h snmp_msg.h err.h udp.h netdb.h snmp.h netifapi.h init.h netbuf.h sockets.h netif.h timers.h sio.h mem.h raw.h opt.h debug.h pbuf.h memp.h arch.h api.h snmp_asn1.h api_msg.h snmp_structs.h sys.h dns.h tcp.h dhcp.h tcpip.h memp_std.h stats.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: ip_frag.h inet.h autoip.h ip.h inet_chksum.h igmp.h ip_addr.h icmp.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/raw_http_basic_example
    ../../: raw_http_basic_example_samd20.c
  group thirdparty/lwip/raw_http_basic_example/network
    ../../network/: ethernet.c timer_mgt.c timer_mgt.h ethernet.h
  group thirdparty/lwip/raw_http_basic_example/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c fs.c fsdata.h httpd.h fs.h
  group thirdparty/lwip/raw_http_basic_example/samd20_xplained_pro
    ../: conf_eth.h conf_board.h lwipopts.h conf_extint.h conf_spi.h conf_clocks.h
  group thirdparty/lwip/raw_http_basic_example/samd20_xplained_pro/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: sam0_spi_ksz8851snl.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: sam0_spi_ksz8851snl.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: perf.h cc.h
  group sam0/utils
    ../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/stdio
    ../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../sam0/utils/cmsis/samd20/include/: samd20e17.h samd20g17.h samd20.h samd20e18.h samd20j18.h samd20j15.h samd20j14.h samd20e16.h samd20j16.h samd20g14.h samd20g17u.h samd20g15.h samd20g18u.h samd20g18.h samd20j17.h samd20e15.h samd20g16.h samd20e14.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../sam0/utils/cmsis/samd20/include/instance/: adc.h sercom2.h sercom0.h sercom4.h pac1.h evsys.h pac0.h port.h eic.h sysctrl.h nvmctrl.h tc1.h dsu.h tc3.h tc5.h rtc.h pm.h tc7.h sercom5.h tc0.h tc4.h dac.h tc2.h sercom3.h ac.h gclk.h wdt.h tc6.h sercom1.h pac2.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../sam0/utils/cmsis/samd20/include/component/: pac.h gclk.h port.h sercom.h dsu.h eic.h tc.h evsys.h dac.h rtc.h adc.h sysctrl.h nvmctrl.h wdt.h ac.h pm.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../sam0/utils/cmsis/samd20/include/pio/: samd20g18u.h samd20g16.h samd20j16.h samd20g15.h samd20j14.h samd20g14.h samd20g17u.h samd20g18.h samd20g17.h samd20e18.h samd20e16.h samd20j18.h samd20e15.h samd20j17.h samd20e17.h samd20j15.h samd20e14.h
  group sam0/utils/preprocessor
    ../../../../../sam0/utils/preprocessor/: tpaste.h preprocessor.h stringz.h mrepeat.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../sam0/drivers/system/clock/clock_samd20/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/tc
    ../../../../../sam0/drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/sercom
    ../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/spi
    ../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/usart
    ../../../../../sam0/drivers/sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/extint
    ../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/components/ethernet_phy/ksz8851snl
    ../../../../../sam0/components/ethernet_phy/ksz8851snl/: ksz8851snl.c ksz8851snl_reg.h ksz8851snl.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
